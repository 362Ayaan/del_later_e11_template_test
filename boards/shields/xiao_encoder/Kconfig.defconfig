## boards/shields/xiao_encoder/Kconfig.defconfig
```kconfig
if SHIELD_XIAO_ENCODER

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "xiao-encoder"

endif
```
